# Keil uVision project Project.uvprojx, settings and files
target FlashProject (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM3
  c include: ..\CoreSupport\Include;..\CMSIS\Include;..\Config;..\BSP\inc;..\Fatfs\src;..\RTT
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../CoreSupport/Source/Templates/ARM/: startup_LPC177x_8x.s
  group CMSIS-CM3
    ../CoreSupport/Source/Templates/: system_LPC177x_8x.c
    ../CMSIS/Lib/: arm_cortexM3l_math.lib
  group Main
    ./Source/: main.c
  group BSP
    ../BSP/src/: EMC.c
  group Fatfs
    ../Fatfs/src/: diskio.c ff.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
